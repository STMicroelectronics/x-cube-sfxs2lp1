# IAR project S2868A1_Sigfox_CLI_Monarch.ewp, settings and files
configuration S2868A1_Sigfox_CLI_Monarch (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Utilities/CLI; ../../../../../Middlewares/Third_Party/Sigfox/Sigfox_STM32_Library/Inc; ../../../../../Middlewares/Third_Party/Sigfox/Sigfox/Inc; ../../../../../Drivers/BSP/S2868A1; ../../../../../Drivers/BSP/Components/S2LP; ../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: S2868A1_Sigfox_CLI_Monarch.bin
  ILINK.IlinkOutputFile: S2868A1_Sigfox_CLI_Monarch.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: app_x_cube_sfxs2lp1.c main.c s2lp_management.c sfx_config.c sfx_demo_cli_commands.c stm32l4xx_hal_msp.c stm32l4xx_it.c stm32l4xx_nucleo.c stm32l4xx_nucleo_bus.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/S2LP/: s2lp.c
    ../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/src/: S2LP_Commands.c S2LP_Csma.c S2LP_Fifo.c S2LP_General.c S2LP_Gpio.c S2LP_PacketHandler.c S2LP_PktBasic.c S2LP_PktStack.c S2LP_PktWMbus.c S2LP_Qi.c S2LP_Radio.c S2LP_Timer.c S2LP_Timer_ex.c S2LP_Types.c
  group Drivers/BSP/S2868A1
    ../../../../../Drivers/BSP/S2868A1/: s2868a1.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/X-CUBE-SFXS2LP1/Network/Sigfox/sigfox_library
    ../../../../../Middlewares/Third_Party/Sigfox/Sigfox/Lib/RF_Library/: ADDON_RF_PROTOCOL_MON_CM4_IAR.a
    ../../../../../Middlewares/Third_Party/Sigfox/Sigfox/Lib/Sigfox_Library/: SFX_LIB_MON_CM4_IAR.a
  group Middlewares/X-CUBE-SFXS2LP1/Network/Sigfox/sigfox_st_library
    ../../../../../Middlewares/Third_Party/Sigfox/Sigfox_STM32_Library/Src/: mcu_api.c nvm_api.c rf_api.c
    ../../../../../Middlewares/Third_Party/Sigfox/Sigfox_STM32_Library/Lib/Monarch/: ST_MONARCH_LIB_CM4_IAR.a
    ../../../../../Middlewares/Third_Party/Sigfox/Sigfox_STM32_Library/Lib/Retriever/: ST_RETRIEVER_LIB_CM4_IAR.a
  group Middlewares/X-CUBE-SUBG2/Documentation
    ../../../../../Drivers/BSP/S2868A1/: readme.txt
  group Utilities
    ../../../../../Utilities/CLI/: command-interpreter2.c response.c serial_utils.c utils.c
