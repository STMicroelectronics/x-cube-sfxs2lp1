# Keil uVision project S2868A1_Sigfox_CLI_Monarch.uvprojx, settings and files
target S2868A1_Sigfox_CLI_Monarch (ARM-ADS)
  device: STM32L073RZTx STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: S2868A1_Sigfox_CLI_Monarch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L073xx
  c include: ../Inc;../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Utilities/CLI;../../../../../Middlewares/Third_Party/Sigfox/Sigfox_STM32_Library/Inc;../../../../../Middlewares/Third_Party/Sigfox/Sigfox/Inc;../../../../../Drivers/BSP/S2868A1;../../../../../Drivers/BSP/Components/S2LP;../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/inc
  group Application/MDK-ARM
    ./: startup_stm32l073xx.s
  group Application/User
    ../Src/: main.c sfx_demo_cli_commands.c sfx_config.c app_x_cube_sfxs2lp1.c s2lp_management.c stm32l0xx_nucleo_bus.c stm32l0xx_nucleo.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/S2LP/: s2lp.c
    ../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/src/: S2LP_Commands.c S2LP_Csma.c S2LP_Fifo.c S2LP_General.c S2LP_Gpio.c S2LP_PacketHandler.c S2LP_PktBasic.c S2LP_PktStack.c S2LP_PktWMbus.c S2LP_Qi.c S2LP_Radio.c S2LP_Timer.c S2LP_Timer_ex.c S2LP_Types.c
  group Drivers/BSP/S2868A1
    ../../../../../Drivers/BSP/S2868A1/: s2868a1.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Middlewares/X-CUBE-SFXS2LP1/Network/Sigfox/sigfox_st_library
    ../../../../../Middlewares/Third_Party/Sigfox/Sigfox_STM32_Library/Lib/Monarch/: ST_MONARCH_LIB_CM0+_Keil.a
    ../../../../../Middlewares/Third_Party/Sigfox/Sigfox_STM32_Library/Lib/Retriever/: ST_RETRIEVER_LIB_CM0+_Keil.a
    ../../../../../Middlewares/Third_Party/Sigfox/Sigfox_STM32_Library/Src/: mcu_api.c nvm_api.c rf_api.c
  group Middlewares/X-CUBE-SFXS2LP1/Network/Sigfox/sigfox_library
    ../../../../../Middlewares/Third_Party/Sigfox/Sigfox/Lib/RF_Library/: ADDON_RF_PROTOCOL_MON_CM0+_Keil.a
    ../../../../../Middlewares/Third_Party/Sigfox/Sigfox/Lib/Sigfox_Library/: SFX_LIB_MON_CM0+_Keil.a
  group Middlewares/X-CUBE-SUBG2/Documentation
    ../../../../../Drivers/BSP/S2868A1/: readme.txt
  group Utilities
    ../../../../../Utilities/CLI/: command-interpreter2.c response.c serial_utils.c utils.c
software components: CMSIS:CORE 4.3.0
